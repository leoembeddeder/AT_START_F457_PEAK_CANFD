# Keil uVision project transceiver_standby_mode.uvprojx, settings and files
target transceiver_standby_mode (6240000::V6.24::ARMCLANG)
  device: AT32F457ZET7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: transceiver_standby_mode +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=3
  c define: AT32F457ZET7,USE_STDPERIPH_DRIVER,AT_START_F457_V1
  c include: ..\inc;..\..\..\..\..\at32f45x_board;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\..\libraries\drivers\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group user
    ../src/: at32f45x_clock.c at32f45x_int.c main.c
  group bsp
    ../../../../../at32f45x_board/: at32f45x_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f45x_gpio.c at32f45x_misc.c at32f45x_crm.c at32f45x_usart.c at32f45x_pwc.c at32f45x_can.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f45x.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f45x.s
  group readme
    ../: readme.txt
